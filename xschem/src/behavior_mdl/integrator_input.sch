v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {type=primitive
format="@name @pinlist @symname"
template="name=x1"}
E {}
L 4 50 -30 50 50 {}
L 4 50 -30 130 10 {}
L 4 50 50 130 10 {}
L 4 130 10 160 10 {}
L 4 40 10 50 10 {}
L 4 20 10 40 10 {}
L 4 20 0 20 20 {}
L 4 -20 20 20 20 {}
L 4 -20 0 -20 20 {}
L 4 -20 0 20 0 {}
L 4 30 -50 30 10 {}
L 4 30 -50 70 -50 {}
L 4 70 -60 70 -40 {}
L 4 80 -60 80 -40 {}
L 4 80 -50 140 -50 {}
L 4 140 -50 140 10 {}
L 4 -50 10 -20 10 {}
B 5 -52.5 7.5 -47.5 12.5 {name=in
dir=inout}
B 5 157.5 7.5 162.5 12.5 {name=out
dir=inout}
T {R1} -10 20 0 0 0.2 0.2 {}
T {CF} 70 -40 0 0 0.2 0.2 {}
